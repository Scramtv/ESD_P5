options:
  parameters:
    author: Grp 5-125
    copyright: 'Yes'
    description: 'No'
    generate_options: no_gui
    id: GNUinput
    output_language: python
    run_options: run
    title: Data_In
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: 2420.875e6
  states: {}
- name: pass_band
  id: variable
  parameters:
    value: 41.75e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\solva\Desktop\GitHub\ESD5\ESD_P5\04 Prototype udvikling\Front end\RX-frontend V.1\Data_test.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\solva\Desktop\GitHub\ESD5\ESD_P5\04 Prototype udvikling\Front end\RX-frontend V.1\Data_test1.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="50Samples",
                  in_sig=[np.complex64, np.float32],
                  out_sig=[np.complex64, np.float32]
              )
              self.count = 0

          def work(self, input_items, output_items):
              in_data = input_items[0]
              in_flag = input_items[1]
              out_data = output_items[0]
              out_flag = output_items[1]

              n_input_data = len(in_data)
              n_input_flag = len(in_flag)
              n_output_data = len(out_data)
              n_output_flag = len(out_flag)

              samples_written = 0

              for i in range(min(n_input_data, n_input_flag, n_output_data, n_output_flag)):
                  if in_flag[i] > 0.5:
                  
                      if self.count < 50:
                              out_data[samples_written] = in_data[i]
                              out_flag[samples_written] = 0.0
                              self.count += 1
                              samples_written += 1

                      if self.count < 60:
                              out_flag[samples_written] = 1.0
                              self.count += 1
                              samples_written += 1
                      else:
                              break
           
                  else:
                      samples_writtesn = 0
                      break

              return samples_written
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="50Samples",
                  in_sig=[np.complex64, np.float32],
                  out_sig=[np.complex64, np.float32]
              )
              self.count = 0

          def work(self, input_items, output_items):
              in_data = input_items[0]
              in_flag = input_items[1]
              out_data = output_items[0]
              out_flag = output_items[1]

              n_input_data = len(in_data)
              n_input_flag = len(in_flag)
              n_output_data = len(out_data)
              n_output_flag = len(out_flag)

              samples_written = 0

              for i in range(min(n_input_data, n_input_flag, n_output_data, n_output_flag)):
                  if in_flag[i] > 0.5:
                  
                      if self.count < 50:
                              out_data[samples_written] = in_data[i]
                              out_flag[samples_written] = 0.0
                              self.count += 1
                              samples_written += 1

                      if self.count < 60:
                              out_flag[samples_written] = 1.0
                              self.count += 1
                              samples_written += 1
                      else:
                              break
           
                  else:
                      samples_writtwn = 0
                      break

              return samples_written
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    alias: osmocom_src
    args: bladerf=0,nchan=2
    bb_gain0: '0'
    bb_gain1: '0'
    bw0: pass_band
    bw1: pass_band
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: cent_freq
    freq1: cent_freq
    gain0: '0'
    gain1: '0'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '0'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_const_source_x_0, '0', epy_block_0_0, '1']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '1', blocks_null_sink_0_0, '0']
- [epy_block_0_0, '0', blocks_file_sink_0_1, '0']
- [epy_block_0_0, '1', blocks_null_sink_0, '0']
- [osmosdr_source_0, '0', epy_block_0, '0']
- [osmosdr_source_0, '1', epy_block_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
