options:
  parameters:
    author: lille-koch
    generate_options: no_gui
    id: Frontend
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RF_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: band_pass
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 2441.75e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: band_pass
    center_freq: cent_freq
    dev_args: bladrf=0,channel=0
    gain: RF_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: band_pass
    center_freq: cent_freq
    dev_args: bladrf=0,channel=1
    gain: RF_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: complex
  states: {}

connections:
- [soapy_bladerf_source_0, '0', zeromq_pub_sink_0, '0']
- [soapy_bladerf_source_0_0, '0', zeromq_pub_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
