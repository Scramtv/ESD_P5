options:
  parameters:
    author: ESD 5-125
    copyright: 'Yes'
    generate_options: no_gui
    id: Frontend_V2
    output_language: python
    title: Frontend
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: 2413.916e6
  states: {}
- name: pass_band
  id: variable
  parameters:
    value: 27.83e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6/2
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\solva\Desktop\GitHub\ESD5\ESD_P5\04 Prototype udvikling\Front end\RX-frontend V.2\DataRX1.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\solva\Desktop\GitHub\ESD5\ESD_P5\04 Prototype udvikling\Front end\RX-frontend V.2\DataRX2.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: C:\Users\solva\Desktop\GitHub\ESD5\ESD_P5\04 Prototype udvikling\Front end\RX-frontend V.2\Flag_Data.txt
    type: float
    unbuffered: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Numb_Sample: '1'
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      from operator import index

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block that takes samples passes them, when a input flag does high then it will tka 50 new"""

          def __init__(self, Numb_Sample = 1.0):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name = 'Samples',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64, np.float32], #RX1, RX2, Flag_move
                  out_sig=[np.complex64, np.complex64, np.float32] #RX1, RX2, Flag_meas_done
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              self.Numb_Sample = Numb_Sample

          def work(self, input_items, output_items):

              output_amount = 0
              for i in range(len(input_items[0])):
                  if input_items[2][i] > 0.5:
                      output_items[0][i] = input_items[0][i]
                      output_items[1][i] = input_items[1][i]
                      output_items[2][i] = 0.0
                      output_amount+=1
                  else:

                      output_items[0][i] = 0
                      output_items[1][i] = 0

                  output_items[2][i] = 1.0


              return output_amount
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,nchan=2
    bb_gain0: '0'
    bb_gain1: '0'
    bw0: pass_band
    bw1: pass_band
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: cent_freq
    freq1: cent_freq
    gain0: '0'
    gain1: '0'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '0'
    if_gain1: '0'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '2']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '1', blocks_file_sink_1, '0']
- [epy_block_0, '2', blocks_file_sink_2, '0']
- [osmosdr_source_0, '0', epy_block_0, '0']
- [osmosdr_source_0, '1', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
